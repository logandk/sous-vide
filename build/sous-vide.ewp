# IAR project sous-vide.ewp, settings and files
configuration sous-vide (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303xC ST STM32F303xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F30X
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\include; ..\lib\STM32F30x; ..\lib\STM32F30x_StdPeriph_Driver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: sous-vide.srec
  ILINK.IlinkOutputFile: sous-vide.out
  ILINK.IlinkIcfFile: stm32f30x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARM
    ./: startup_stm32f30x.s
  group STM32F30x
    ../lib/STM32F30x/: system_stm32f30x.c
  group STM32F30x_StdPeriph_Driver
    ../lib/STM32F30x_StdPeriph_Driver/src/: stm32f30x_gpio.c stm32f30x_misc.c stm32f30x_rcc.c stm32f30x_tim.c
  group User
    ../src/: main.c pid.c stm32f30x_lcd.c stm32f30x_sleep.c stm32f30x_temp.c stm32f30x_timer.c
